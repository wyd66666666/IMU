# Keil uVision project IMU_BM1270_BMM350.uvprojx, settings and files
target IMU_BM1270_BMM350 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IMU_BM1270_BMM350 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../HARDWARE/BMI270;../HARDWARE/BMM350;../HARDWARE/common;../HARDWARE/DELAY;../HARDWARE/PRINTF;../HARDWARE/ANONY_PROTOCOL;../HARDWARE/IMU_ATTITUDE;../HARDWARE/BMP580;../HARDWARE/IIC;..\HARDWARE\CALIBRATION;..\HARDWARE\EKF
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6200
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cortex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group HARDWARE
    ../HARDWARE/BMI270/: bmi2.c bmi270.c
    ../HARDWARE/common/: common.c bmi270_bmm350.c
    ../HARDWARE/BMM350/: bmm350.c
    ../HARDWARE/DELAY/: delay.c
    ../HARDWARE/PRINTF/: usart_printf.c
    ../HARDWARE/ANONY_PROTOCOL/: anony_protocol.c
    ../HARDWARE/IMU_ATTITUDE/: imu_attitude.c
    ../HARDWARE/BMP580/: bmp5.c bmp5_port.c
    ../HARDWARE/IIC/: myiic.c bmp580_i2c.c
    ../HARDWARE/CALIBRATION/: sensor_calibration.c
    ../HARDWARE/EKF/: ekf_fusion.c fusion_filter.c
software components: CMSIS:CORE 6.1.0
